Commit message: URDF 进行机器人建模

File: ROS2/Code/10_URDF_model/src/robot_model/urdf/robot_model.urdf (robot description, URDF)
Before this commit: robot fishbot, 7 links, 6 joints
Links:
- link base_link: geometry visual cylinder length=0.12 radius=0.1
